# Keil uVision project LWIP.uvprojx, settings and files
target LWIP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LWIP +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F2xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_eth.c stm32f2xx_hal_tim.c stm32f2xx_hal_rcc.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_uart.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c icmp6.c ip6.c dhcp6.c mld6.c nd6.c inet6.c ip6_addr.c ethip6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: demand.c pppos.c chap-new.c ecp.c chap-md5.c eui64.c ipv6cp.c chap_ms.c multilink.c ccp.c pppoe.c mppe.c utils.c ppp.c upap.c auth.c fsm.c ipcp.c eap.c vj.c lcp.c magic.c pppcrypt.c pppol2tp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c ip4_addr.c autoip.c ip4.c ip_frag.c dhcp.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/core/: udp.c lwip_timers.c mem.c inet_chksum.c def.c tcp.c sys.c memp.c tcp_in.c init.c raw.c stats.c dns.c netif.c tcp_out.c pbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/api/: netdb.c netifapi.c err.c sockets.c netbuf.c api_lib.c api_msg.c pppapi.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c md4.c arc4.c des.c sha1.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application/User
    ../Src/: gpio.c ethernetif.c stm32f2xx_hal_msp.c usart.c main.c stm32f2xx_it.c lwip.c tcp_echoclient.c tcp_echoserver.c app_ethernet.c
software components: CMSIS:CORE 4.1.0
